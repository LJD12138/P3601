# Keil uVision project BOOT.uvprojx, settings and files
target BOOT (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303RE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.5.0
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BOOT +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  AfterMake: .\Keil5_disp_size_bar_v0.4.exe
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c misc: --no-multibyte-chars
  c include: .\Firmware\CMSIS;.\Firmware\GD32F30x_standard_peripheral\Include;.\Firmware\CMSIS\GD\GD32F30x\Include;.\Application;.\ComFunc;.\Middlewares\SeggerRtt;.\Middlewares\LightweightRingBuffer\src;.\Middlewares\EasyFlash\inc;.\Middlewares\Protocol;.\Middlewares\MultiFuncKey;.\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc7ff
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ./Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_xd.s
  group CMSIS
    ./Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Peripherals
    ./Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group MW-SeggerRtt
    ./Middlewares/SeggerRtt/: Seeger_print.c SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group MW-Lwrb
    ./Middlewares/LightweightRingBuffer/src/: lwrb.c lwrb.h lwrb_ex.c
  group MW-EasyFlash
    ./Middlewares/EasyFlash/src/: easyflash.c ef_env.c ef_iap.c ef_log.c ef_utils.c
    ./Middlewares/EasyFlash/port/: ef_port.c
    ./Middlewares/EasyFlash/inc/: easyflash.h ef_cfg.h ef_def.h
  group MW-Protocol
    ./Middlewares/Protocol/Modbus/: modbus_proto.c modbus_proto.h
    ./Middlewares/Protocol/Baiku/: baiku_proto.c baiku_proto.h
    ./Middlewares/Protocol/: proto_update.c proto_update.h
  group MW-MultiFuncKey
    ./Middlewares/MultiFuncKey/: mf_key.c mf_key.h
  group ComFunc
    ./ComFunc/: check.c function.c i2c.c filtration.c ntc.c queue_task.c
  group Application
    ./Application/: board_config.h main.c boot_info.c board_config.c timer_task.c gpio_init.c systick.c gd32f30x_it.c rtc_wakeup.c fwdgt.c
  group App-Sys
    ./Application/Sys/: sys_task.c sys_task.h sys_queue_task.c sys_queue_task.h sys_queue_task_init.c sys_queue_task_dispaly.c sys_queue_task_enter_app.c sys_queue_task_low_power.c sys_queue_task_err.c sys_queue_task_reset.c sys_queue_task_update.c
  group HW-Update
    ./Hardware/Update/: baiku_proto.c baiku_proto.h update_main.c update_main.h xmodem_proto.c xmodem_proto.h
  group HW-Print
    ./Hardware/Print/: print_task.c print_task.h print_api.c print_api.h print_iface.c print_iface.h print_prot_frame.c print_prot_frame.h print_queue_task.c print_queue_task.h print_queue_task_main.c
  group HW-Flash
    ./Hardware/Flash/: flash_gd32.c flash_gd32.h flash_iface.c flash_iface.h
  group HW-Key
    ./Hardware/Key/: key_func.c key_func.h key_iface.c key_iface.h key_task.c key_task.h
  group HW-Led
    ./Hardware/Led/: led_iface.c led_iface.h led_task.c led_task.h
  group HW-Adc
    ./Hardware/Adc/: adc_task.c adc_task.h adc_iface.c adc_iface.h
  group HW-MD_Bms
    ./Hardware/MD_Bms/: md_bms_task.c md_bms_task.h md_bms_queue_task.c md_bms_queue_task.h md_bms_queue_task_main.c md_bms_queue_task_update.c md_bms_rec_task.c md_bms_rec_task.h md_bms_rec_data_proc.c md_bms_rec_data_proc.h md_bms_prot_frame.c md_bms_prot_frame.h md_bms_iface.c md_bms_iface.h
  group HW-MD_Disp
    ./Hardware/MD_Display/: md_display_iface.c md_display_iface.h md_display_task.c md_display_task.h md_display_api.c md_display_api.h
